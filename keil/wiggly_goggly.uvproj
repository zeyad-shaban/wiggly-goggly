# Keil uVision project wiggly_goggly.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: wiggly_goggly +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../code/: ultrasonic_logic.inc uart.inc main.asm LCD.inc delay.inc
